# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,SENSOR,MBEDTLS_CONFIG_FILE=<aws_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,AWS,USE_WIFI
  c misc: --C99
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../Inc;../../../../../Common/AWS/inc;../../../../../Common/Shared/inc;../../../../../../Middlewares/Third_Party/AWS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/vl53l0x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Application/User
    ../Src/: vl53l0x_platform.c vl53l0x_proximity.c stm32l4xx_hal_msp.c stm32l4xx_it.c main.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: sha256.c des.c x509.c ecjpake.c pkparse.c sha1.c cipher.c threading.c ssl_tls.c asn1write.c md_wrap.c debug.c ctr_drbg.c cmac.c ecp_curves.c ssl_cache.c x509_csr.c oid.c cipher_wrap.c md.c hmac_drbg.c pkcs5.c x509_crl.c sha512.c error.c ccm.c havege.c ecp.c bignum.c padlock.c ecdh.c version_features.c md5.c x509_create.c certs.c pkcs11.c pk_wrap.c aes.c platform.c blowfish.c pem.c md4.c pk.c arc4.c entropy.c aesni.c x509write_crt.c md2.c ssl_cli.c ripemd160.c asn1parse.c camellia.c version.c ssl_ticket.c ssl_ciphersuites.c base64.c ssl_srv.c entropy_poll.c ecdsa.c rsa.c pkwrite.c pkcs12.c gcm.c ssl_cookie.c x509write_csr.c dhm.c x509_crt.c timing.c xtea.c memory_buffer_alloc.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_strings.c vl53l0x_api_core.c vl53l0x_platform_log.c vl53l0x_api_ranging.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_tsensor.c stm32l475e_iot01.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_psensor.c stm32l475e_iot01_magneto.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Application/AWS
    ../../../../../Common/AWS/Src/: aws_timer.c aws_network_st_wrapper.c aws_subscribe_publish_sensor_values.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/AWS
    ../../../../../../Middlewares/Third_Party/AWS/src/: aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_yield.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dfsdm.c stm32l4xx_hal_cryp.c stm32l4xx_ll_fmc.c stm32l4xx_hal_dac.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal.c stm32l4xx_hal_hash.c stm32l4xx_hal_crc.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_spi.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_qspi.c stm32l4xx_hal_nor.c stm32l4xx_hal_cortex.c stm32l4xx_hal_usart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_flash.c stm32l4xx_hal_lptim.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_i2c.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_sram.c
  group Application/Common
    ../Src/: flash_l4.c
    ../../../../../Common/Shared/Src/: http_util.c iot_flash_config.c net.c entropy_hardware_poll.c sensors_data.c wifi_net.c timedate.c rfu.c STM32CubeRTCInterface.c mbedtls_patch.c firewall_wrapper.c net_tls_mbedtls.c heap.c net_tcp_wifi.c net_tcp_lwip.c cloud.c mbedtls_net.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/Wifi
    ../Src/: wifi.c es_wifi_io.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
target B-L475E-IOT01-NOSENSOR (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.3.0
  cpu: as above
  output: B-L475E-IOT01-NOSENSOR
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<aws_mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,USE_MBED_TLS,AWS,RFU,USE_WIFI
  c misc: --C99
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../Inc;../Inc;../../../../../Common/AWS/inc;../../../../../Common/Shared/inc;../../../../../../Middlewares/Third_Party/AWS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/vl53l0x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
software components: CMSIS:CORE 4.3.0
